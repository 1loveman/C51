# Keil uVision project muban.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: muban +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Basic;.\Hardware;.\User
  group User
    ./: STARTUP.A51
    ./User/: main.c
  group Basic
    ./Basic/: DELAY.c TIMER.c
  group Hardware
    ./Hardware/: SG90.c UT.c KEY.c VABRATION.c 433.c BUZZER.c
